# Keil uVision project H1DRx.uvprojx, settings and files
target Module 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Module 1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H1DR5,_module=1
  c include: ..\User;..\H1DR5;..\BOS;..\Thirdparty\Middleware\FreeRTOS\Source\CMSIS_RTOS;..\Thirdparty\Middleware\FreeRTOS\Source\include;..\Thirdparty\Middleware\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\Thirdparty\STM32F0xx_HAL_Driver\Inc\Legacy;..\Thirdparty\STM32F0xx_HAL_Driver\Inc;..\Thirdparty\CMSIS\Device\ST\STM32F0xx\Include;..\Thirdparty\CMSIS\Include;..\Thirdparty\BSP\Components\enc28j60;..\Thirdparty\Middleware\FreeRTOS-Plus-UDP\include;..\Thirdparty\Middleware\FreeRTOS-Plus-UDP\portable\Compiler\RVDS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c
  group CMSIS
    ../thirdparty/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group STM32F0xx_HAL_Driver
    ../thirdparty/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
    ../Thirdparty/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c
  group BITZ/BOS
    ../BOS/: BOS.c BOS_CLI.c BOS_eeprom.c BOS_freertos.c
  group BITZ/H1DR5
    ../H1DR5/: H1DR5.c H1DR5_dma.c H1DR5_gpio.c H1DR5_it.c H1DR5_spi.c H1DR5_uart.c startup_stm32f091xc.s udp_cli_commands.c
  group FreeRTOS
    ../thirdparty/Middleware/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_CLI.c list.c queue.c tasks.c timers.c
    ../thirdparty/Middleware/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../thirdparty/Middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../thirdparty/Middleware/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group FreeRTOS_Plus_UDP
    ../Thirdparty/Middleware/FreeRTOS-Plus-UDP/: FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_Sockets.c FreeRTOS_UDP_IP.c
    ../Thirdparty/Middleware/FreeRTOS-Plus-UDP/portable/BufferManagement/: BufferAllocation_2.c
    ../Thirdparty/Middleware/FreeRTOS-Plus-UDP/portable/NetworkInterface/enc28j60/: NetworkInterface.c
  group Enc28j60
    ../Thirdparty/BSP/Components/enc28j60/: enc28j60.c
